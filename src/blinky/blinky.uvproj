# Keil uVision project blinky.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: blinky +hex (library)
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Includes;..\..\peripherials;..\..\peripherials\Inc
  group Sources
    ./Sources/: main.c
  group Peripherials
    ../../peripherials/Src/: led.c seg.c delay.c beeper.c keys.c
